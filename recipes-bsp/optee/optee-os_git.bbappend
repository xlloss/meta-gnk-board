FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

COMPATIBLE_MACHINE_rzv2l = "(gnk-rzv2l)"
COMPATIBLE_MACHINE_rzg2l = "(gnk-rzg2l)"
COMPATIBLE_MACHINE_rzg2l = "(apollo-rzg2l)"
PLATFORM_FLAVOR_apollo-rzg2l = "g2l_apollo_board"
