FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-support-gnk-board-dts.patch \
	file://0002-support-gnk-board-config.patch \
	file://0001-gnk-g2l-support-smarc-rzg2l-gnk-board.patch \
	file://0001-CONF-add-apollo-board.patch \
	file://0001-SDHC-CH1-fixed-sdcard-read-fail.patch \
	file://0001-LOW_LEVEL_CONG-add-panel-check-script-on-boot.patch \
	"

